SUMMARY = "Package group for adding Monk OS specific Open Source Components"

LICENSE = "GPLv3"

inherit packagegroup

PACKAGES = "\
        packagegroup-monkos-baserootfs \
        "

RDEPENDS_packagegroup-monkos-baserootfs = "\
        "
